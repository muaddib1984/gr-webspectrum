options:
  parameters:
    author: muaddib
    generate_options: no_gui
    id: RTLSDR_or_fake_signal_to_fft_to_broadcaster
    output_language: python
    run_options: run
    title: Signal Content Portion of Web Based Spectrum Display
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.038'
    comment: WIDEBAND SIGNAL
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    comment: NOISE FLOOR
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.0075'
    comment: NARROWBAND SIGNAL
    freq: '-922e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.007'
    comment: NARROWBAND SIGNAL
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft size
    short_id: n
    type: intx
    value: '8192'
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 100e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '40.0'
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: '10'
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: WIDEBAND SIGNAL
    cutoff_freq: 300e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 60e3
    win: window.WIN_HAMMING
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: '------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      FAKE MULTI CARRIER SIGNAL
      NOISE FLOOR ACCROSS SPECTRUM
      2 NARROWBAND CARRIERS
      AND 1 WIDEBAND CARRIER
      (NO RADIO REQUIRED)
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      --------------------------------------------------------------------------------------
      RADIO SOURCE (DISABLE THE 
      FAKE SIGNAL IF YOU'RE GONNA USE THIS)
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: '--------------------------------------------------------------------------------------'
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    comment: '--------------------------------------------------------------------------------------'
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    comment: |-
      --------------------------------------------------------------------------------------
      DSP SECTION
      SAME BLOCKS AS 'server.py'
      FROM WATERFALL PROJECT
  states: {}
- name: note_0_1_1_0
  id: note
  parameters:
    comment: |-
      --------------------------------------------------------------------------------------
      Connection to Redis Backend
  states: {}
- name: note_0_1_1_0_0
  id: note
  parameters:
    comment: '--------------------------------------------------------------------------------------'
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_12
  id: note
  parameters:
    comment: |-
      -
       
      COMMAND LINE PARAMETERS
      WHEN WE USE PARAMETER BLOCKS
      THE GENERATED PYTHON WILL
      NOW HAVE A --help/-h menu
      --------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
  states: {}
- name: note_1_0
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_0_0_0
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_0_1_0
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_1
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
  states: {}
- name: note_1_1_0
  id: note
  parameters:
    comment: |-
      I
      I
      I
      I
      I
      I
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: eng_float
    value: 2.88e6
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: frequency
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: webspectrum_broadcaster_0
  id: webspectrum_broadcaster
  parameters:
    fft_size: '8192'
    freq: 100e6
    gain: '40.0'
    redis_host: '''localhost'''
    redis_port: '6379'
    redis_stream: spectral
    samp_rate: 2.88e6
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8001'
  states: {}

connections:
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '3']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', throttle, '0']
- [logpwrfft_x_0, '0', webspectrum_broadcaster_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', logpwrfft_x_0, '0']
- [throttle, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
